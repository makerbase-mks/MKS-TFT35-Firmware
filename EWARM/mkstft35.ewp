# IAR project mkstft35.ewp, settings and files
configuration mkstft35 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; STM32F40_41xxx; USE_HAL_LIB; TFT35
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: ..\Inc\dump_define.h
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Middlewares\Third_Party\FatFs\src\drivers; ..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Middlewares\Third_Party\FatFs\src; ..\Drivers\CMSIS\Include; ..\Drivers\STM32F4xx_MKS_Driver\Inc; ..\Drivers\STM32F4xx_MKS_Driver\Src; ..\Drivers\libstmf4; ..\Drivers\libstmf4\include; ..\Middlewares\Repetier; ..\Middlewares\Repetier\inc_dumb; ..\Middlewares\Repetier\inc_reserve; ..\Middlewares\arduino\stm32\cores\arduino; ..\User\ui; ..\User\others; ..\User\uart_model; ..\User\others\Multi_language; ..\User\others\QRENCODE; ..\Middlewares\GUI
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: mkstft35.bin
  ILINK.IlinkOutputFile: mkstft35.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\Middlewares\GUI\GUI.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mksRobinPro (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; STM32F40_41xxx; USE_HAL_LIB
  ICCARM.PreInclude: E:\MKS TFT70 V1.0_001 ZL\cs6\mkstft70\trunk\mkstft70\Middlewares\Repetier\dump_define.h
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include; ../Drivers/STM32F4xx_MKS_Driver/Inc; ../Drivers/STM32F4xx_MKS_Driver/Src; ../Drivers/libstmf4; ../Drivers/libstmf4/include; ../Middlewares/Repetier; ../Middlewares/Repetier/inc_dumb; ../Middlewares/Repetier/inc_reserve; ../Middlewares/arduino/stm32/cores/arduino; ../User/ui; ../User/others; ../Middlewares/Ucgui; ../Middlewares/Ucgui/GUI/ConvertColor; ../Middlewares/Ucgui/GUI/ConvertMono; ../Middlewares/Ucgui/GUI/Core; ../Middlewares/Ucgui/GUI/Font; ../Middlewares/Ucgui/AntiAlias; ../Middlewares/Ucgui/GUI/GUIDemo; ../Middlewares/Ucgui/GUI/LCDDriver; ../Middlewares/Ucgui/GUI/MemDev; ../Middlewares/Ucgui/GUI/MultiLayer; ../Middlewares/Ucgui/GUI/Widget; ../Middlewares/Ucgui/GUI/WM; ../Middlewares/Ucgui/GUI_X; ../Middlewares/Ucgui/Config; ..\User\uart_model
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: mkstft70.bin
  ILINK.IlinkOutputFile: mkstft70.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ../Src/: adc.c bsp_driver_sd.c dac.c dma.c fatfs.c fsmc.c gpio.c i2c.c iwdg.c main.cpp rtc.c sdio.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c usb_host.c usbh_conf.c
  group Application/User/others
    ../User/others/Multi_language/: Font24_MS.c multi_language.cpp
    ../User/others/: fontHz18.c fs_usr.cpp ili9320.c mks_cfg.cpp mks_fontHz14.c mks_touch_screen.c pic.c pic_manager.cpp sd_usr.cpp string_deal.c touch_calibrate.cpp wifi_module.cpp wifi_upload.cpp
  group Application/User/QRENCODE
    ../User/others/QRENCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group Application/User/uart_model
    ../User/uart_model/: mks_tft_fifo.cpp mks_tft_function.c mks_tft_gcode.cpp mks_tft_protocol.c mks_tft_reprint.cpp mks_tft_test.cpp MKS_USART2_IT.cpp
  group Application/User/UI
    ../User/ui/: draw_about.cpp draw_babyStep.cpp draw_bind.cpp draw_change_speed.cpp draw_dialog.cpp draw_disk.cpp draw_extrusion.cpp draw_fan.cpp draw_filamentchange.cpp draw_FileTransfer_ui.cpp draw_language.cpp draw_log_ui.cpp draw_machine.cpp draw_main.cpp draw_manual_leveling.cpp draw_more.cpp draw_move_motor.cpp draw_operate.cpp draw_pause_ui.cpp draw_pre_heat.cpp draw_print_file.cpp draw_printing.cpp draw_printing_moremenu.cpp draw_ready_print.cpp draw_set.cpp draw_Sprayer.cpp draw_temp_ui.cpp draw_tool.cpp draw_ui.cpp draw_wifi.cpp draw_zero.cpp draw_zoffset.cpp id_manage.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/libstmf4
    ../Drivers/libstmf4/source/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Drivers/STM32F4xx_MKS_Driver
    ../Drivers/STM32F4xx_MKS_Driver/Src/: spi_flash.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: mycc936.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c usbh_diskio.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
