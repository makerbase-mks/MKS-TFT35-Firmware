<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>mkstft35</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>mksRobinPro</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f407xx.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <group>
        <name>others</name>
        <file>
          <name>$PROJ_DIR$\..\User\others\Multi_language\Font24_MS.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\fontHz18.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\fs_usr.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\Multi_language\Helvetica26.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\Multi_language\Helvetica36.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\ili9320.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\mks_cfg.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\mks_fontHz14.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\mks_touch_screen.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\Multi_language\multi_language.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\pic.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\pic_manager.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\sd_usr.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\string_deal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\touch_calibrate.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\wifi_module.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\wifi_upload.cpp</name>
        </file>
      </group>
      <group>
        <name>QRENCODE</name>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\bitstream.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\mask.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\mmask.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\mqrspec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\QR_Encode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\qrencode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\qrinput.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\qrspec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\rscode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\others\QRENCODE\split.c</name>
        </file>
      </group>
      <group>
        <name>uart_model</name>
        <file>
          <name>$PROJ_DIR$\..\User\uart_model\mks_tft_fifo.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\uart_model\mks_tft_function.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\uart_model\mks_tft_gcode.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\uart_model\mks_tft_protocol.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\uart_model\mks_tft_reprint.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\uart_model\mks_tft_test.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\uart_model\MKS_USART2_IT.cpp</name>
        </file>
      </group>
      <group>
        <name>UI</name>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_about.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_acceleration.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_advanced.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_autoLeveling.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_babyStep.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_baud_rate.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_bind.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_buttonConf.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_change_speed.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_current_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_CustomConf.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_dialog.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_disk.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_display_conf.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_extrusion.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_fan.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_filament_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_filamentchange.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_FileTransfer_ui.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_firmware_type.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_keyboard.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_language.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_leveling_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_levelingPara_config.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_log_ui.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_machine.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_machine_para.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_machine_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_machine_type.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_main.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_manual_leveling.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_MaxFeedRate.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_more.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_MoreBtns.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_motor_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_move_motor.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_number_key.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_operate.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_Pause_pos.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_pause_ui.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_pre_heat.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_print_file.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_printing.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_printing_moremenu.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_printMoreBtn.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_ready_print.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_set.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_Sprayer.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_steps.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_temp_ui.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_temperature_settings.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_Tips.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_TMC_sensitivity.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_tool.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_ui.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_wifi.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_wifi_list.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_XYZLevelPara.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_zero.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\draw_zoffset.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\ui\id_manage.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Src\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\bsp_driver_sd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\fatfs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usb_host.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usbh_conf.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>libstmf4</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\libstmf4\source\stm32f4xx_usart.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dac_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_hcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_sd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_sram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_sdmmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_usb.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_MKS_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_MKS_Driver\Src\spi_flash.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>FatFs</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\ff.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\ff_gen_drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\option\mycc936.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\drivers\sd_diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\option\syscall.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\drivers\usbh_diskio.c</name>
      </file>
    </group>
    <group>
      <name>USB_Host_Library</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Host_Library\Core\Src\usbh_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Host_Library\Core\Src\usbh_ctlreq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Host_Library\Core\Src\usbh_ioreq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_bot.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_scsi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Host_Library\Core\Src\usbh_pipes.c</name>
      </file>
    </group>
  </group>
</project>


